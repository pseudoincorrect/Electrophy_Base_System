# Keil uVision project embedded_base.uvproj, settings and files
target embedded_base Configuration (ARM-ADS)
  device: STM32F411VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: embedded_base Configuration
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Src;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c DAC.c ElectrophyData.c NRF.c usb_device.c usbd_audio_if.c usbd_conf.c usbd_desc.c FBAR.c
  group midleware
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c usbd_audio_if_template.c
